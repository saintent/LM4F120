# IAR project LightSensor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM4F120H5QR; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCIncludePath2: $WS_DIR$\driverlib; $WS_DIR$\grlib; $WS_DIR$\grlib\fonts; $WS_DIR$\grlib\binfonts; $WS_DIR$\inc; $WS_DIR$\usblib; $WS_DIR$\usblib\device; $WS_DIR$\usblib\host; $WS_DIR$\utils; $WS_DIR$\; 01.inc\; 02.src\; 03.lib\; 04.start_up\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.IccLang: 1
  group 02.src
    02.src/: LedMatrix.c lightSensor.c main.c system.c
  group 03.lib
    03.lib/: driverlib-cm4f.a
  group 04.start_up
    04.start_up/: startup_ewarm.c
