# IAR project PWM_DEMO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM4F120H5QR; TARGET_IS_BLIZZARD_RA1; UART_BUFFERED
  ICCARM.CCIncludePath2: $WS_DIR$\driverlib; $WS_DIR$\grlib; $WS_DIR$\grlib\fonts; $WS_DIR$\grlib\binfonts; $WS_DIR$\inc; $WS_DIR$\usblib; $WS_DIR$\usblib\device; $WS_DIR$\usblib\host; $WS_DIR$\utils; $WS_DIR$\03.lib; $WS_DIR$\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ewarm; PART_LM4F120H5QR; TARGET_IS_BLIZZARD_RA1; UART_BUFFERED
  ICCARM.CCOptLevel: 3
  group 02.src
    ../utils/: cmdline.c uartstdio.c
    02.src/: main.c
  group 03.lib
    ../03.lib/: driverlib-cm4f.a
  group 05.startup
    02.src/: startup_ewarm.c
