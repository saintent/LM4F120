# IAR project LM4F120.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM4F120H5QR; TARGET_IS_BLIZZARD_RA1; UART_BUFFERED
  ICCARM.CCIncludePath2: $WS_DIR$\driverlib; $WS_DIR$\grlib; $WS_DIR$\grlib\fonts; $WS_DIR$\grlib\binfonts; $WS_DIR$\inc; $WS_DIR$\usblib; $WS_DIR$\usblib\device; $WS_DIR$\usblib\host; $WS_DIR$\utils; $WS_DIR$\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.ADefines: ewarm; PART_LM4F120H5QR; TARGET_IS_BLIZZARD_RA1
  OBJCOPY.OOCOutputFile: LM4F120.bin
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: C:\StellarisWare\boards\ek-lm4f120xl\project0\project0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 5.srec
  group Libraries
    lib/: driverlib-cm4f.a
  group Source
    ../utils/: cmdline.c uartstdio.c
    Source/: main.cpp
    ../: startup_ewarm.c
